# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151x6 ST STM32L151x6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: CMSIS\CM3\DeviceSupport\ST\STM32L1xx\startup\iar\; CMSIS\CM3\CoreSupport\; CMSIS\CM3\DeviceSupport\ST\STM32L1xx\; STM32L1xx_StdPeriph_Driver\inc\; CMSIS\Device\ST\STM32L1xx\Include\; CMSIS\Device\ST\STM32L1xx\Source\Templates\iar\; ; Usb\; STM32_USB-FS-Device_Driver\inc\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: project.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c
  group CMSIS
    CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_md.s
    CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group core
    CMSIS/Include/: arm_common_tables.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h
  group STDP
    STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
    STM32L1xx_StdPeriph_Driver/inc/: misc.h stm32l1xx_adc.h stm32l1xx_aes.h stm32l1xx_comp.h stm32l1xx_crc.h stm32l1xx_dac.h stm32l1xx_dbgmcu.h stm32l1xx_dma.h stm32l1xx_exti.h stm32l1xx_flash.h stm32l1xx_fsmc.h stm32l1xx_gpio.h stm32l1xx_i2c.h stm32l1xx_iwdg.h stm32l1xx_lcd.h stm32l1xx_opamp.h stm32l1xx_pwr.h stm32l1xx_rcc.h stm32l1xx_rtc.h stm32l1xx_sdio.h stm32l1xx_spi.h stm32l1xx_syscfg.h stm32l1xx_tim.h stm32l1xx_usart.h stm32l1xx_wwdg.h
  group USB lib
    STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
    STM32_USB-FS-Device_Driver/inc/: otgd_fs_cal.h otgd_fs_dev.h otgd_fs_int.h otgd_fs_pcd.h otgd_fs_regs.h usb_core.h usb_def.h usb_init.h usb_int.h usb_lib.h usb_mem.h usb_regs.h usb_sil.h usb_type.h
  group USB lib src
    Usb/: hw_config.c hw_config.h usb_conf.h usb_desc.c usb_desc.h usb_endp.c usb_istr.c usb_istr.h usb_prop.c usb_prop.h usb_pwr.c usb_pwr.h
  group Uses
    ./: stm32l1xx_conf.h stm32l1xx_it.c stm32l1xx_it.h
